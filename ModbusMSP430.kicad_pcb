# Repository penoud/ModbusMSP430

## KiCad design ModbusMSP430.kicad_pcb

Parts:
C1, C2: 10uF
C3, C4: 22uF
C5, C6: 100nF
C7, C8: 10pF
J1, J2: RJ45
LOGO1: OPEN_HARDWARE_1
P1, P2: CONN_01X10
P15: CONN_01X04
P16, P17, P18, P19: CONN_01X01
Q1: BSS138; SOT-23
R1: 100K
R2, R3: 10K
U1: AZ1117C-3.3
U2: AZ1117C-5.0
U3: MSP430G2553IPW20; 20PW
U4: MAX481
Y1: CRYSTAL

Connections:
+3V3: C3.1, C5.1, P1.1, R1.1, U1.2 (VO), U3.1 (DVCC)
+5V: C4.1, P15.3, R3.2, U2.2 (VO), U4.8 (VCC)
+12V: C1.1, C2.1, J1.3, J1.4, J2.3, J2.4, U1.3 (VI), U2.3 (VI)
/Direction: Q1.3 (D), R3.1, U4.2 (nRE), U4.3 (DE)
/FAN_CMD: C6.1, P1.8, P15.1, U3.8 (P2.0/TA1.0)
/P1.0: P1.2, U3.2 (TA0CLK/ACLK/CA0/A0/P1.0)
/P1.3: P1.5, U3.5 (CAOUT/VREF-/VeREF-/CA3/A3/P1.3)
/P1.4: P1.6, U3.6 (TCK/SMCLK/UCB0STE/UCA0CLK/VREF+/VeREF+/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)
/P1.5: P1.7, U3.7 (TMS/UCB0CLK/UCA0STE/TA0.0/CA5/A5/P1.5)
/P1.6: P2.7, U3.14 (TDI/TCLK/UCB0SOMI/UCB0SCL/TA0.1/CA6/A6/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)
/P1.7: P2.6, U3.15 (TDO/TDI/UCB0SIMO/UCB0SDA/CAOUT/CA7/A7/P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)
/P2.1: P1.9, U3.9 (P2.1/TA1.1)
/P2.2: P1.10, U3.10 (P2.2/TA1.1)
/P2.3: P2.10, U3.11 (P2.3/TA1.0)
/P2.4: P2.9, U3.12 (P2.4/TA1.2)
/P2.5: P2.8, U3.13 (P2.5/TA1.2)
/P2.6: C7.1, P2.2, U3.19 (P2.6/XIN/TA0.1), Y1.1
/P2.7: C8.1, P2.3, U3.18 (P2.7/XOUT), Y1.2
/RS485_N: J1.5, J1.7, J2.5, J2.7, U4.7 (B)
/RS485_P: J1.6, J1.8, J2.6, J2.8, U4.6 (A)
/RST: P2.5, R1.2, U3.16 (~RST~/NMI/SBWTDIO)
/RX: P1.3, U3.3 (UCA0RXD/UCA0SOMI/TA0.0/CA1/A1/P1.1), U4.1 (RX)
/TEST: P2.4, U3.17 (TEST/SBWTCK)
/TX: P1.4, R2.1, U3.4 (UCA0TXD/UCA0SIMO/TA0.1/CA2/A2/P1.2), U4.4 (TX)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, J1.1, J1.2, J2.1, J2.2, P2.1, P15.4, P16.1, P17.1, P18.1, P19.1, Q1.2 (S), U1.1 (GND/ADJ), U2.1 (GND/ADJ), U3.20 (DVSS), U4.5 (GND)
unnamed: Q1.1 (G), R2.2

Board: 2 copper layers, 69.8 x 47.0 mm, 26 parts (8 on the bottom side), 26 nets.

## Commit log

2015-06-12 first revision
